# Keil uVision project STM32F407ZGTx.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407ZGTx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User;..\User\app;..\User\bsp;..\RTOS\include;..\RTOS\include\libc;..\RTOS\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group USER
    ../User/: stm32f4xx_it.c main.c
  group bsp
    ../User/bsp/: bsp_delay.c bsp_gpio.c bsp_usart.c
    ../User/app/: App_Test.c
  group app
    ../User/app/: App_Led.c App_Key.c
  group RTOS/Source
    ../RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTOS/ports
    ../RTOS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group RTOSConfig
    ../User/: board.c rtconfig.h
